# Repository fablabnk/DaisySeedProjects

## KiCad design Hardware/GuitarPedal1590b_2Layer/pcb/DaisySeedPedal1590b.kicad_pcb

Parts:
A1: Electrosmith_Daisy_Seed_Rev4; Electrosmith_Daisy_Seed
J1: Barrel_Jack; Generic_PowerJack
J2: AUDIO_IN_TRS; NEUTRIK_NMJ6HCD2; PARTREV 26.02.2021
J3: AUDIO_OUT_TRS; NEUTRIK_NMJ6HCD2; PARTREV 26.02.2021
J4: MIDI IN JACK; TRRS-PJ-320A
J5: MIDI OUT JACK; TRRS-PJ-320A

Connections:
+3.3V: A1.38 (3V3_D); also elsewhere on the board
+3.3VA: A1.21 (3V3_A); also elsewhere on the board
+9V: A1.39 (VIN); also elsewhere on the board
AUDIO_IN_BUFFER_LEFT: A1.16 (AUDIO_IN_1); also elsewhere on the board
AUDIO_IN_BUFFER_RIGHT: A1.17 (AUDIO_IN_2); also elsewhere on the board
AUDIO_IN_JACK_LEFT: J2.T; also elsewhere on the board
AUDIO_IN_JACK_RIGHT: J2.R; also elsewhere on the board
AUDIO_OUT_BUFFER_LEFT: A1.18 (AUDIO_OUT_1); also elsewhere on the board
AUDIO_OUT_BUFFER_RIGHT: A1.19 (AUDIO_OUT_2); also elsewhere on the board
AUDIO_OUT_JACK_LEFT: J3.T; also elsewhere on the board
AUDIO_OUT_JACK_RIGHT: J3.R; also elsewhere on the board
FOOT_SWITCH_1: A1.7 (SD_CLK); also elsewhere on the board
FOOT_SWITCH_2: A1.6 (SD_CMD); also elsewhere on the board
GND: A1.20 (AGND), A1.40 (DGND), J1.1, J1.3, J2.RN, J2.S, J2.SN, J2.TN, J3.RN, J3.S, J3.SN, J3.TN, J4.S, J5.S; also elsewhere on the board
LED_1: A1.29 (DAC_OUT2); also elsewhere on the board
LED_2: A1.30 (DAC_OUT1); also elsewhere on the board
MIDI_IN: A1.37 (USB_D_+); also elsewhere on the board
MIDI_IN_JACK_PIN4: J4.R1; also elsewhere on the board
MIDI_IN_JACK_PIN5: J4.T; also elsewhere on the board
MIDI_OUT: A1.36 (USB_D_-); also elsewhere on the board
MIDI_OUT_JACK_PIN4: J5.R1; also elsewhere on the board
MIDI_OUT_JACK_PIN5: J5.T; also elsewhere on the board
POT_1: A1.22 (ADC_0); also elsewhere on the board
POT_2: A1.23 (ADC_1); also elsewhere on the board
POT_3: A1.24 (ADC_2); also elsewhere on the board
POT_4: A1.25 (ADC_3); also elsewhere on the board
POWER_JACK_PWR: J1.2; also elsewhere on the board

Parts:
C7, C8: 100NF; C_Rect_L7.2mm_W3.0mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C9, C10: 10UF; C_Disc_D6.0mm_W2.5mm_P5.00mm
R1, R2, R4, R5: 2M; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R3, R6: 100K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
U3: MCP6004; DIP-14_W7.62mm

Connections:
+5V_ISOLATED_POWER: C7.1, C8.1, R3.1, U3.4 (V+); also elsewhere on the board
/Audio Input Buffer/V_AUDIOBIAS: R4.1, R5.1, U3.6 (-), U3.7
AUDIO_IN_BUFFER_LEFT: U3.13 (-), U3.14; also elsewhere on the board
AUDIO_IN_BUFFER_RIGHT: U3.1, U3.2 (-); also elsewhere on the board
AUDIO_IN_JACK_LEFT: C9.1, R1.1; also elsewhere on the board
AUDIO_IN_JACK_RIGHT: C10.1, R2.1; also elsewhere on the board
GND: C7.2, C8.2, R1.2, R2.2, R6.2, U3.10 (+), U3.11 (V-); also elsewhere on the board
unnamed: C10.2, R5.2, U3.3 (+)
unnamed: R3.2, R6.1, U3.5 (+)
unnamed: U3.8, U3.9 (-)
unnamed: C9.2, R4.2, U3.12 (+)

Parts:
C1, C4, C5: 10UF; C_Disc_D6.0mm_W2.5mm_P5.00mm
C2, C3: 100NF; C_Rect_L7.2mm_W3.0mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C6: 22UF; CP_Radial_D4.0mm_P2.00mm
D1: 1N5817; D_DO-35_SOD27_P7.62mm_Horizontal
L1: 2.2uH; L_Radial_D7.0mm_P3.00mm
R21: DNP; R_0805_2012Metric
U1: L4931CZ50; TO-92_Inline_Wide
U2: PDS1-S5-S5-D; CONV_PDS1-S5-S5-D

Connections:
+5V: C4.1, L1.1, R21.1, U1.1 (VO)
+5V_ISOLATED_POWER: C6.1, R21.2, U2.5 (+VO); also elsewhere on the board
+9V: C1.1, C2.1, C3.1, D1.1 (K), U1.3 (VI); also elsewhere on the board
/Power/VIN: C5.1, L1.2, U2.4 (VIN)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, U1.2 (GND), U2.1 (GND), U2.7 (0V); also elsewhere on the board
POWER_JACK_PWR: D1.2 (A); also elsewhere on the board

Parts:
C11, C12, C15, C16: 10UF; C_Disc_D6.0mm_W2.5mm_P5.00mm
C13, C14: 100NF; C_Rect_L7.2mm_W3.0mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
R7, R8, R9, R10, R13, R14: 2M; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R11, R12: 100R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
U4: OPA2134; DIP-8_W7.62mm

Connections:
+5V_ISOLATED_POWER: C13.1, C14.1, R7.1, R9.1, U4.8 (V+); also elsewhere on the board
AUDIO_OUT_BUFFER_LEFT: C11.2; also elsewhere on the board
AUDIO_OUT_BUFFER_RIGHT: C12.2; also elsewhere on the board
AUDIO_OUT_JACK_LEFT: C15.2, R13.1; also elsewhere on the board
AUDIO_OUT_JACK_RIGHT: C16.2, R14.1; also elsewhere on the board
GND: C13.2, C14.2, R8.2, R10.2, R13.2, R14.2, U4.4 (V-); also elsewhere on the board
unnamed: C15.1, R11.2
unnamed: C16.1, R12.2
unnamed: C12.1, R9.2, R10.1, U4.3 (+)
unnamed: R12.1, U4.1, U4.2 (-)
unnamed: C11.1, R7.2, R8.1, U4.5 (+)
unnamed: R11.1, U4.6 (-), U4.7

Parts:
FS1: Foot_Switch_1; PinHeader_1x02_P2.54mm_Vertical
FS2: Foot_Switch_2; PinHeader_1x02_P2.54mm_Vertical
LED1: LED_1; PinHeader_1x02_P2.54mm_Vertical
LED2: LED_2; PinHeader_1x02_P2.54mm_Vertical
POT1, POT2, POT3, POT4: 10K; Pot_RightAngle_LongPin_16mm
R19, R20: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal

Connections:
+3.3VA: POT1.3, POT2.3, POT3.3, POT4.3; also elsewhere on the board
FOOT_SWITCH_1: FS1.2; also elsewhere on the board
FOOT_SWITCH_2: FS2.2; also elsewhere on the board
GND: FS1.1, FS2.1, LED1.1 (K), LED2.1 (K), POT1.1, POT2.1, POT3.1, POT4.1; also elsewhere on the board
LED_1: R19.2; also elsewhere on the board
LED_2: R20.2; also elsewhere on the board
unnamed: LED1.2 (A), R19.1
unnamed: LED2.2 (A), R20.1
POT_1: POT1.2; also elsewhere on the board
POT_2: POT2.2; also elsewhere on the board
POT_3: POT3.2; also elsewhere on the board
POT_4: POT4.2; also elsewhere on the board

Parts:
C17: 100NF; C_Disc_D6.0mm_W2.5mm_P5.00mm
D2: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
R15: 220R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R16: 33R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R17: 10R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R18: 470R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
U5: H11L1; DIP-6_W7.62mm

Connections:
+3.3V: C17.1, R16.2, R18.1, U5.6; also elsewhere on the board
GND: C17.2, U5.5; also elsewhere on the board
MIDI_IN: R18.2, U5.4; also elsewhere on the board
MIDI_IN_JACK_PIN4: R15.1; also elsewhere on the board
MIDI_IN_JACK_PIN5: D2.2 (A), U5.2; also elsewhere on the board
MIDI_OUT: R17.2; also elsewhere on the board
MIDI_OUT_JACK_PIN4: R16.1; also elsewhere on the board
MIDI_OUT_JACK_PIN5: R17.1; also elsewhere on the board
unnamed: D2.1 (K), R15.2, U5.1

Notes on the sheet:
Based on the Midi TRS Standard for 3.3v

Board: 2 copper layers, 54.0 x 106.0 mm, 60 parts (0 on the bottom side), 44 nets.

File Hardware/GuitarPedal1590b_2Layer/pcb/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
A1,Electrosmith_Daisy_Seed,1,Electrosmith_Daisy_Seed_Rev4,
"C1, C10, C11, C12, C15, C16, C4, C5, C9",C_Disc_D6.0mm_W2.5mm_P5.00mm,9,10UF,
"C13, C14, C2, C3, C7, C8",C_Rect_L7.2mm_W3.0mm_P5.00mm_FKS2_FKP2_MKS2_MKP2,6,100NF,
C17,C_Disc_D6.0mm_W2.5mm_P5.00mm,1,100NF,
C6,CP_Radial_D4.0mm_P2.00mm,1,22UF,
D1,D_DO-35_SOD27_P7.62mm_Horizontal,1,1N5817,
D2,D_DO-35_SOD27_P7.62mm_Horizontal,1,1N4148,
FS1,PinHeader_1x02_P2.54mm_Vertical,1,Foot_Switch_1,
FS2,PinHeader_1x02_P2.54mm_Vertical,1,Foot_Switch_2,
J1,Generic_PowerJack,1,Barrel_Jack,
J2,NEUTRIK_NMJ6HCD2,1,AUDIO_IN_TRS,
J3,NEUTRIK_NMJ6HCD2,1,AUDIO_OUT_TRS,
J4,TRRS-PJ-320A,1,MIDI IN JACK,
J5,TRRS-PJ-320A,1,MIDI OUT JACK,
L1,L_Radial_D7.0mm_P3.00mm,1,2.2uH,
LED1,PinHeader_1x02_P2.54mm_Vertical,1,LED_1,
LED2,PinHeader_1x02_P2.54mm_Vertical,1,LED_2,
"POT1, POT2, POT3, POT4",Pot_RightAngle_LongPin_16mm,4,10K,
"R1, R10, R13, R14, R2, R4, R5, R7, R8, R9",R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal,10,2M,
"R11, R12",R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal,2,100R,
R15,R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal,1,220R,
R16,R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal,1,33R,
R17,R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal,1,10R,
R18,R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal,1,470R,
"R19, R20",R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal,2,1K,
R21,0805,1,DNP,
"R3, R6",R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal,2,100K,
U1,TO-92_Inline_Wide,1,L4931CZ50,
U2,CONV_PDS1-S5-S5-D,1,PDS1-S5-S5-D,
U3,DIP-14_W7.62mm,1,MCP6004,
U4,DIP-8_W7.62mm,1,OPA2134,
U5,DIP-6_W7.62mm,1,H11L1,

## Commit log

2024-12-01 added 2-layer PCB design for through hole GuitarPedal1590b
